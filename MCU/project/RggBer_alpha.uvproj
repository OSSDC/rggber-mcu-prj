# Keil uVision project RggBer_alpha.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F410 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0x7FFF) CLOCK(50000000)
  output: RggBer_alpha +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\inc
  group Source Group 1
    ../source/: main.c
    ../lib/: AF.c Dev.c EDID.c I2C.C OV5640.c SPI0.c
